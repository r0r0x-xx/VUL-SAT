options:
  parameters:
    author: r0r0x
    description: SDR-agnostic LoRa downlink receiver (RTL-SDR or HackRF via GNU Radio's native Soapy blocks)
    generate_options: no_gui
    id: PwnsatLoraRX
    output_language: python
    title: PwnsatLoraRX
  states: {}

blocks:
- name: bandpass
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: bandwidth/2
    low_cutoff_freq: '-bandwidth/2'
    samp_rate: samp_rate
    type: complex_band_pass
    width: bandwidth/50
    win: window.WIN_HAMMING
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: coding_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '916000000'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_header
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: device_args
  id: variable
  parameters:
    comment: 'SoapySDR driver name: "rtlsdr" for RTL-SDR, "hackrf" for HackRF'
    value: '"rtlsdr"'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: bb_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bandwidth
  states: {}
- name: spread_factor
  id: variable
  parameters:
    value: '7'
  states: {}
- name: zmq_address
  id: variable
  parameters:
    value: '"tcp://0.0.0.0:5005"'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: bandpass
    type: ccc
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: ''
    bandwidth0: bandwidth
    center_freq0: frequency
    dc_removal0: 'False'
    dev_args: '""'
    driver: device_args
    gain0: rf_gain
    samp_rate: samp_rate
    settings0: '""'
    stream_args: '""'
    tune_args0: '""'
    type: fc32
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: spread_factor
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_address
    hwm: '1000'
    timeout: '100'
    type: byte
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', lora_rx_0, '0']
- [soapy_custom_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [lora_rx_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
